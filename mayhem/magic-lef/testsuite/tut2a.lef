VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO tut2a
  CLASS BLOCK ;
  FOREIGN tut2a ;
  ORIGIN 40.000 -3.000 ;
  SIZE 32.000 BY 4.000 ;
END tut2a
END LIBRARY

