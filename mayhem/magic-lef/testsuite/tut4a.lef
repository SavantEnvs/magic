VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO tut4a
  CLASS BLOCK ;
  FOREIGN tut4a ;
  ORIGIN 71.000 116.000 ;
  SIZE 213.000 BY 200.000 ;
END tut4a
END LIBRARY

